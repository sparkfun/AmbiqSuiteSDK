# Keil uVision project cache_monitor.uvprojx, settings and files
target cache_monitor (ARM-ADS)
  device: AMA3B1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.1.0
  cpu: IRAM(0x10000000,0x00060000) IROM(0x0000C000,0x000F4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: cache_monitor
  AfterMake: fromelf --bin --output bin\cache_monitor.bin bin\cache_monitor.axf
  AfterMake: fromelf -cedrst --output bin\cache_monitor.txt bin\cache_monitor.axf
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PART_APOLLO3 AM_PACKAGE_BGA FIREBALL_CARD APS6404L keil
  c include: ../../../../../utils;../../../../../mcu/apollo3;../../../../../CMSIS/AmbiqMicro/Include;../../../../../devices;../../../../../CMSIS/ARM/Include;../../../bsp;../../../../..;../src
  memory RVCT4: ROM 0xC000 size 0xF4000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\cache_monitor.sct
  link misc: ../../../../../mcu/apollo3/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group prime_mpi_src
    ../../../../../third_party/prime_mpi/src/: prime_mpi.c
  group src
    ../src/: cache_monitor.c
  group devices
    ../../../../../devices/: am_devices_fireball.c am_devices_mspi_psram.c
  group utils
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../bsp/keil/bin/: libam_bsp.lib
    ../../../../../mcu/apollo3/hal/keil/bin/: libam_hal.lib
