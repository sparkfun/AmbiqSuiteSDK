# Keil uVision project mspi_flash_loader.uvprojx, settings and files
target mspi_flash_loader (ARM-ADS)
  device: AMA3B1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.1.0
  cpu: IRAM(0x10000000,0x00060000) IROM(0x0000C000,0x000F4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: mspi_flash_loader
  AfterMake: fromelf --bin --output bin\mspi_flash_loader.bin bin\mspi_flash_loader.axf
  AfterMake: fromelf -cedrst --output bin\mspi_flash_loader.txt bin\mspi_flash_loader.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: FIREBALL_CARD AM_PACKAGE_BGA AM_UTIL_FAULTISR_PRINT AM_PART_APOLLO3 ADESTO_ATXP032 keil
  c include: ../../../../..;../../../bsp;../../../../../utils;../../../../../CMSIS/ARM/Include;../src;../../../../../mcu/apollo3;../../../../../CMSIS/AmbiqMicro/Include;../../../../../devices
  memory RVCT4: ROM 0xC000 size 0xF4000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\mspi_flash_loader.sct
  link misc: ../../../../../mcu/apollo3/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group src
    ../src/: mspi_flash_loader.c
  group devices
    ../../../../../devices/: am_devices_fireball.c am_devices_mspi_flash.c
  group utils
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../bsp/keil/bin/: libam_bsp.lib
    ../../../../../mcu/apollo3/hal/keil/bin/: libam_hal.lib
