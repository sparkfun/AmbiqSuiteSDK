# Keil uVision project adc_lpmode0_dma.uvprojx, settings and files
target adc_lpmode0_dma (ARM-ADS)
  device: AMA3B1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.1.0
  cpu: IRAM(0x10000000,0x00060000) IROM(0x0000C000,0x000F4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: adc_lpmode0_dma
  AfterMake: fromelf --bin --output bin\adc_lpmode0_dma.bin bin\adc_lpmode0_dma.axf
  AfterMake: fromelf -cedrst --output bin\adc_lpmode0_dma.txt bin\adc_lpmode0_dma.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PART_APOLLO3 AM_PACKAGE_BGA keil
  c include: ../../../bsp;../../../../../utils;../../../../../mcu/apollo3;../../../../../CMSIS/ARM/Include;../../../../../devices;../../../../../CMSIS/AmbiqMicro/Include;../../../../..;../src
  memory RVCT4: ROM 0xC000 size 0xF4000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\adc_lpmode0_dma.sct
  link misc: ../../../../../mcu/apollo3/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group src
    ../src/: adc_lpmode0_dma.c
  group utils
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group devices
    ../../../../../devices/: am_devices_led.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../../mcu/apollo3/hal/keil/bin/: libam_hal.lib
    ../../../bsp/keil/bin/: libam_bsp.lib
