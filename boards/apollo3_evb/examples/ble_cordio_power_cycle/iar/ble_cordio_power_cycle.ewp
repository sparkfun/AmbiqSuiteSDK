# IAR project ble_cordio_power_cycle.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMA3B1KK-KBR AmbiqMicro AMA3B1KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; WSF_TRACE_ENABLED; AM_PACKAGE_BGA; AM_PART_APOLLO3; AM_DEBUG_PRINTF; AM_CUSTOM_BDADDR
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\utils; ..\..\..\..\..\third_party\exactle\sw\services; ..\..\..\..\..\third_party\exactle\sw\profiles\fmpl; ..\..\..\..\..\third_party\exactle\sw\stack\hci; ..\..\..\..\..; ..\..\..\..\..\third_party\exactle\ws-core\sw\util; ..\..\..\..\..\third_party\exactle\sw\profiles\hid; ..\..\..\..\..\third_party\exactle\sw\profiles\gatt; ..\..\..\..\..\third_party\uecc\micro-ecc; ..\..\..\..\..\mcu\apollo3; ..\..\..\bsp; ..\..\..\..\..\third_party\exactle\ws-core\include; ..\..\..\..\..\third_party\exactle\sw\profiles\uribeacon; ..\..\..\..\..\third_party\exactle\apollo-host\projects\common; ..\..\..\..\..\third_party\exactle\sw\sec\common; ..\..\..\..\..\devices; ..\..\..\..\..\third_party\exactle\sw\hci\include; ..\..\..\..\..\third_party\exactle\sw\apps\app\include; ..\..\..\..\..\third_party\exactle\sw\profiles\wdxs; ..\..\..\..\..\third_party\exactle\sw\profiles\gap; ..\..\..\..\..\third_party\exactle\sw\profiles\bas; ..\..\..\..\..\third_party\exactle\sw\apps\tag; ..\..\..\..\..\third_party\exactle\sw\stack\cfg; ..\..\..\..\..\third_party\exactle\sw\hci\ambiq\apollo3; ..\..\..\..\..\third_party\exactle\sw\apps\app; ..\..\..\..\..\third_party\exactle\sw\sec\include; ..\..\..\..\..\third_party\exactle\sw\hci\ambiq; ..\src; ..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\third_party\exactle\sw\stack\include; ..\..\..\..\..\third_party\exactle\ws-core\sw\wsf\include; ..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\third_party\exactle\ws-core\sw\wsf\ambiq
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ble_cordio_power_cycle.bin
  ILINK.IlinkOutputFile: ble_cordio_power_cycle.out
  ILINK.IlinkIcfFile: ble_cordio_power_cycle.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\third_party\exactle\projects\generic\stacklib\iar\bin\libstacklib.a; ..\..\..\..\..\third_party\uecc\iar\bin\lib_uecc.a; ..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\mcu\apollo3\hal\iar\bin\libam_hal.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; WSF_TRACE_ENABLED; AM_PACKAGE_BGA; AM_PART_APOLLO3; AM_DEBUG_PRINTF; AM_CUSTOM_BDADDR
  group (top)
    ../../../../../third_party/exactle/sw/apps/app/generic/: app_db.c app_hw.c app_ui.c
    ../../../../../third_party/exactle/sw/profiles/fmpl/: fmpl_main.c
    ../../../../../third_party/exactle/sw/stack/hci/: hci_main.c
    ../../../../../third_party/exactle/sw/sec/common/: sec_aes.c sec_cmac.c sec_ecc_hci.c sec_main.c
    ../../../../../third_party/exactle/ws-core/sw/util/: bda.c bstream.c calc128.c crc32.c print.c terminal.c wstr.c
    ../../../../../third_party/exactle/sw/apps/hidapp/: hidapp_main.c
    ../../../../../third_party/exactle/sw/profiles/hid/: hid_main.c
    ../../../../../third_party/exactle/sw/profiles/gap/: gap_main.c
    ../../../../../third_party/exactle/sw/profiles/gatt/: gatt_main.c
    ../../../../../third_party/exactle/sw/profiles/bas/: bas_main.c
    ../../../../../third_party/exactle/sw/stack/cfg/: cfg_stack.c
    ../../../../../third_party/exactle/sw/hci/ambiq/apollo3/: hci_drv_apollo3.c
    ../../../../../third_party/exactle/ws-core/sw/wsf/common/: wsf_buf.c wsf_efs.c wsf_msg.c wsf_queue.c wsf_timer.c
    ../../../../../third_party/exactle/sw/hci/ambiq/: hci_cmd.c hci_core.c hci_core_ps.c hci_evt.c hci_tr.c hci_vs.c
    ../src/: ble_cordio_power_cycle.c
    ../../../../../third_party/exactle/ws-core/sw/wsf/ambiq/: wsf_assert.c wsf_math.c wsf_os.c wsf_trace.c
    ../../../../../third_party/exactle/sw/apps/tag/: tag_main.c
    ../../../../../utils/: am_util_ble.c am_util_delay.c am_util_faultisr.c am_util_stdio.c
    ../../../../../third_party/exactle/sw/services/: svc_batt.c svc_bps.c svc_core.c svc_cps.c svc_cscs.c svc_dis.c svc_gls.c svc_gyro.c svc_hid.c svc_hrs.c svc_hts.c svc_ipss.c svc_plxs.c svc_px.c svc_rscs.c svc_scpss.c svc_temp.c svc_uricfg.c svc_wdxs.c svc_wp.c svc_wss.c
    ../../../../../third_party/exactle/sw/apps/app/: app_disc.c app_main.c app_master.c app_master_leg.c app_server.c app_slave.c app_slave_leg.c app_terminal.c
    ../../../../../devices/: am_devices_button.c
    ./: startup_iar.c
