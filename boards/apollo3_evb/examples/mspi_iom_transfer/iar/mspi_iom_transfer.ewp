# IAR project mspi_iom_transfer.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMA3B1KK-KBR AmbiqMicro AMA3B1KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; ADESTO_ATXP032; AM_UTIL_FAULTISR_PRINT; FIREBALL_CARD; AM_PACKAGE_BGA; ENABLE_LOGGING; AM_PART_APOLLO3
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..; ..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\mcu\apollo3; ..\src; ..\..\..\..\..\devices; ..\..\..\..\..\utils; ..\..\..\bsp
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: mspi_iom_transfer.bin
  ILINK.IlinkOutputFile: mspi_iom_transfer.out
  ILINK.IlinkIcfFile: mspi_iom_transfer.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\mcu\apollo3\hal\iar\bin\libam_hal.a; ..\..\..\bsp\iar\bin\libam_bsp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; ADESTO_ATXP032; AM_UTIL_FAULTISR_PRINT; FIREBALL_CARD; AM_PACKAGE_BGA; ENABLE_LOGGING; AM_PART_APOLLO3
  group (top)
    ../src/: mspi_iom_transfer.c
    ../../../../../devices/: am_devices_fireball.c am_devices_mb85rs1mt.c am_devices_mspi_flash.c
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
    ./: startup_iar.c
