# Keil uVision project mspi_octal_example.uvprojx, settings and files
target mspi_octal_example (ARM-ADS)
  device: AMA3B2KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.2.0
  cpu: IRAM(0x10000000,0x000C0000) IROM(0x0000C000,0x001F4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: mspi_octal_example
  AfterMake: fromelf --bin --output bin\mspi_octal_example.bin bin\mspi_octal_example.axf
  AfterMake: fromelf -cedrst --output bin\mspi_octal_example.txt bin\mspi_octal_example.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PACKAGE_BGA AM_PART_APOLLO3P AM_UTIL_FAULTISR_PRINT keil
  c include: ../../../bsp;../src;../../../../../devices;../../../../../CMSIS/AmbiqMicro/Include;../../../../..;../../../../../utils;../../../../../CMSIS/ARM/Include;../../../../../mcu/apollo3p
  memory RVCT4: ROM 0xc000 size 0x1f4000
  memory RVCT9: RAM 0x10000000 size 0xc0000
  scatter file: .\linker_script.sct
  link misc: ../../../../../mcu/apollo3p/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group src
    ../src/: mspi_octal_example.c
  group utils
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group devices
    ../../../../../devices/: am_devices_mspi_atxp032.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../bsp/keil/bin/: libam_bsp.lib
    ../../../../../mcu/apollo3p/hal/keil/bin/: libam_hal.lib
