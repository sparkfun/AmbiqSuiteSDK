# IAR project freertos_lowpower.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMA3B2KK-KBR AmbiqMicro AMA3B2KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_FREERTOS; AM_PACKAGE_BGA; AM_UTIL_FAULTISR_PRINT; AM_PART_APOLLO3P; AM_DEBUG_PRINTF
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\third_party\FreeRTOSv10.1.1\Source\include; ..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\utils; ..\src; ..\..\..\..\..\mcu\apollo3p; ..\..\..\bsp; ..\..\..\..\..; ..\..\..\..\..\third_party\FreeRTOSv10.1.1\Source\portable\IAR\AMapollo2; ..\..\..\..\..\devices
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: freertos_lowpower.bin
  ILINK.IlinkOutputFile: freertos_lowpower.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\mcu\apollo3p\hal\iar\bin\libam_hal.a; ..\..\..\bsp\iar\bin\libam_bsp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; AM_FREERTOS; AM_PACKAGE_BGA; AM_UTIL_FAULTISR_PRINT; AM_PART_APOLLO3P; AM_DEBUG_PRINTF
  group (top)
    ../src/: freertos_lowpower.c led_task.c rtos.c
    ../../../../../third_party/FreeRTOSv10.1.1/Source/portable/IAR/AMapollo2/: port.c portasm.s
    ../../../../../third_party/FreeRTOSv10.1.1/Source/portable/MemMang/: heap_2.c
    ../../../../../third_party/FreeRTOSv10.1.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../devices/: am_devices_button.c am_devices_led.c
    ../../../../../utils/: am_util_debug.c am_util_delay.c am_util_faultisr.c am_util_stdio.c
    ./: startup_iar.c
