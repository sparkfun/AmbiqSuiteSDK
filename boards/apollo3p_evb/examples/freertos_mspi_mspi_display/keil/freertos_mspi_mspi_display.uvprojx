# Keil uVision project freertos_mspi_mspi_display.uvprojx, settings and files
target freertos_mspi_mspi_display (ARM-ADS)
  device: AMA3B2KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.2.0
  cpu: IRAM(0x10000000,0x000C0000) IROM(0x0000C000,0x001F4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: freertos_mspi_mspi_display
  AfterMake: fromelf --bin --output bin\freertos_mspi_mspi_display.bin bin\freertos_mspi_mspi_display.axf
  AfterMake: fromelf -cedrst --output bin\freertos_mspi_mspi_display.txt bin\freertos_mspi_mspi_display.axf
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_UTIL_FAULTISR_PRINT AM_FREERTOS APS6404L AM_DEBUG_PRINTF AM_PART_APOLLO3P AM_PACKAGE_BGA keil
  c include: ../../../../../mcu/apollo3p;../src;../../../../../CMSIS/AmbiqMicro/Include;../../../../../devices;../../../../../third_party/FreeRTOSv10.1.1/Source/portable/Keil/AMapollo2;../../../bsp;../../../../../third_party/FreeRTOSv10.1.1/Source/include;../../../../..;../../../../../CMSIS/ARM/Include;../../../../../utils
  memory RVCT4: ROM 0xc000 size 0x1f4000
  memory RVCT9: RAM 0x10000000 size 0xc0000
  scatter file: .\linker_script.sct
  link misc: ../../../../../mcu/apollo3p/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group src
    ../src/: ambiq_logo_bmp.c compose_task.c freertos_mspi_mspi_display.c main_task.c render_task.c rtos.c
  group FreeRTOSv10.1.1_AMapollo2
    ../../../../../third_party/FreeRTOSv10.1.1/Source/portable/Keil/AMapollo2/: port.c
  group utils
    ../../../../../utils/: am_util_debug.c am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group devices
    ../../../../../devices/: am_devices_mspi_psram_aps6404l.c am_devices_mspi_rm67162.c
  group FreeRTOSv10.1.1_MemMang
    ../../../../../third_party/FreeRTOSv10.1.1/Source/portable/MemMang/: heap_2.c
  group FreeRTOSv10.1.1_Source
    ../../../../../third_party/FreeRTOSv10.1.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../bsp/keil/bin/: libam_bsp.lib
    ../../../../../mcu/apollo3p/hal/keil/bin/: libam_hal.lib
