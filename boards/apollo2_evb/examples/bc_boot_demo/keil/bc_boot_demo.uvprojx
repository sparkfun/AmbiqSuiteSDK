# Keil uVision project bc_boot_demo.uvprojx, settings and files
target bc_boot_demo (ARM-ADS)
  device: AMAPH1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.0
  cpu: IRAM(0x10000000,0x40000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bc_boot_demo
  AfterMake: fromelf --bin --output bin\bc_boot_demo.bin bin\bc_boot_demo.axf
  AfterMake: fromelf -cedrst --output bin\bc_boot_demo.txt bin\bc_boot_demo.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PART_APOLLO2 AM_PACKAGE_BGA keil
  c include: ../src;../../../../../utils;../../../bsp;../../../../../mcu/apollo2;../../../../..;../../../../../devices
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x40000
  scatter file: .\bc_boot_demo.sct
  link misc: ../../../../../mcu/apollo2/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group src
    ../src/: bc_boot_demo.c
  group utils
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group devices
    ../../../../../devices/: am_devices_led.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../../mcu/apollo2/hal/keil/bin/: libam_hal.lib
    ../../../bsp/keil/bin/: libam_bsp.lib
