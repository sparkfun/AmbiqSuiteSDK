# IAR project multi_boot.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAPH1KK-KBR AmbiqMicro AMAPH1KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PART_APOLLO2; AM_PACKAGE_BGA; AM_MULTIBOOT_CONFIG_FILE="am_multi_boot_config.h"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\bsp; ..\..\..\..\..\mcu\apollo2; ..\..\..\..\..\bootloader; ..\..\..\..\..; ..\..\..\..\..\utils; ..\src; ..\..\..\..\..\devices
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: multi_boot.bin
  ILINK.IlinkOutputFile: multi_boot.out
  ILINK.IlinkIcfFile: multi_boot.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\mcu\apollo2\hal\iar\bin\libam_hal.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; AM_PART_APOLLO2; AM_PACKAGE_BGA; AM_MULTIBOOT_CONFIG_FILE="am_multi_boot_config.h"
  group (top)
    ../src/: extflash.c multi_boot.c
    ../../../../../utils/: am_util_delay.c am_util_stdio.c
    ../../../../../bootloader/: am_bootloader.c am_ios_boot_handlers.c am_multi_boot.c am_uart_boot_handlers.c
    ../../../../../devices/: am_devices_spiflash.c
    ./: startup_iar.c
