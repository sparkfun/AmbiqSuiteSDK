# Keil uVision project i2c_boot_host.uvprojx, settings and files
target i2c_boot_host (ARM-ADS)
  device: AMAPH1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.0
  cpu: IRAM(0x10000000,0x40000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: i2c_boot_host
  AfterMake: fromelf --bin --output bin\i2c_boot_host.bin bin\i2c_boot_host.axf
  AfterMake: fromelf -cedrst --output bin\i2c_boot_host.txt bin\i2c_boot_host.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PART_APOLLO2 AM_PACKAGE_BGA keil
  c include: ../../../bsp;../../../../../devices;../../../../../utils;../../../../../mcu/apollo2;../src;../../../../..
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x40000
  scatter file: .\i2c_boot_host.sct
  link misc: ../../../../../mcu/apollo2/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group src
    ../src/: i2c_boot_host.c
  group utils
    ../../../../../utils/: am_util_delay.c am_util_stdio.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../bsp/keil/bin/: libam_bsp.lib
    ../../../../../mcu/apollo2/hal/keil/bin/: libam_hal.lib
