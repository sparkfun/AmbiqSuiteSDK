# IAR project ios_fifo_host.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAPH1KK-KBR AmbiqMicro AMAPH1KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA; AM_PART_APOLLO2
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..; ..\..\..\..\..\utils; ..\..\..\..\..\devices; ..\..\..\bsp; ..\src; ..\..\..\..\..\mcu\apollo2
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ios_fifo_host.bin
  ILINK.IlinkOutputFile: ios_fifo_host.out
  ILINK.IlinkIcfFile: ios_fifo_host.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\mcu\apollo2\hal\iar\bin\libam_hal.a; ..\..\..\bsp\iar\bin\libam_bsp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; AM_PACKAGE_BGA; AM_PART_APOLLO2
  group (top)
    ../src/: ios_fifo_host.c
    ../../../../../utils/: am_util_delay.c am_util_stdio.c
    ./: startup_iar.c
