# IAR project rtc_print.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: APOLLO512-KBR AmbiqMicro APOLLO512-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PART_APOLLO; AM_PACKAGE_BGA
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\src; ..\..\..\..\..\mcu\apollo; ..\..\..\bsp; ..\..\..\..\..\utils; ..\..\..\..\..; ..\..\..\..\..\devices
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: rtc_print.bin
  ILINK.IlinkOutputFile: rtc_print.out
  ILINK.IlinkIcfFile: rtc_print.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\mcu\apollo\hal\iar\bin\libam_hal.a; ..\..\..\bsp\iar\bin\libam_bsp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; AM_PART_APOLLO; AM_PACKAGE_BGA
  group (top)
    ../src/: rtc_print.c
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c am_util_string.c am_util_time.c
    ./: startup_iar.c
