# IAR project flash_write.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: APOLLO512-KBR AmbiqMicro APOLLO512-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PART_APOLLO; AM_PACKAGE_BGA
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..; ..\..\..\..\..\utils; ..\..\..\bsp; ..\..\..\..\..\mcu\apollo; ..\..\..\..\..\devices; ..\src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: flash_write.bin
  ILINK.IlinkOutputFile: flash_write.out
  ILINK.IlinkIcfFile: flash_write.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\mcu\apollo\hal\iar\bin\libam_hal.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; AM_PART_APOLLO; AM_PACKAGE_BGA
  group (top)
    ../src/: flash_write.c
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
    ./: startup_iar.c
