# Keil uVision project freertos_lowpower.uvprojx, settings and files
target freertos_lowpower (ARM-ADS)
  device: APOLLO512-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.0
  cpu: IRAM(0x10000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: freertos_lowpower
  AfterMake: fromelf --bin --output bin\freertos_lowpower.bin bin\freertos_lowpower.axf
  AfterMake: fromelf -cedrst --output bin\freertos_lowpower.txt bin\freertos_lowpower.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PACKAGE_BGA AM_DEBUG_PRINTF AM_PART_APOLLO AM_FREERTOS keil
  c include: ../../../bsp;../src;../../../../../utils;../../../../..;../../../../../devices;../../../../../third_party/FreeRTOSv10.1.1/Source/portable/Keil/AMapollo;../../../../../third_party/FreeRTOSv10.1.1/Source/include;../../../../../mcu/apollo
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  scatter file: .\freertos_lowpower.sct
  link misc: ../../../../../mcu/apollo/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group src
    ../src/: freertos_lowpower.c led_task.c rtos.c
  group FreeRTOSv10.1.1_AMapollo
    ../../../../../third_party/FreeRTOSv10.1.1/Source/portable/Keil/AMapollo/: port.c
  group utils
    ../../../../../utils/: am_util_debug.c am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group FreeRTOSv10.1.1_Source
    ../../../../../third_party/FreeRTOSv10.1.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
  group devices
    ../../../../../devices/: am_devices_button.c am_devices_led.c
  group FreeRTOSv10.1.1_MemMang
    ../../../../../third_party/FreeRTOSv10.1.1/Source/portable/MemMang/: heap_2.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../../mcu/apollo/hal/keil/bin/: libam_hal.lib
    ../../../bsp/keil/bin/: libam_bsp.lib
