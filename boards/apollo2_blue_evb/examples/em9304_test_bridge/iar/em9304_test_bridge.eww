<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
      <path>$WS_DIR$\em9304_test_bridge.ewp</path>
  </project>
  <batchBuild/>
</workspace>


