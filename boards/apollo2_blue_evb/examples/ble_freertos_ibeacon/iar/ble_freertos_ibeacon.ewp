# IAR project ble_freertos_ibeacon.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAPH1KK-KBR AmbiqMicro AMAPH1KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PART_APOLLO2; WSF_TRACE_ENABLED; SEC_ECC_CFG=SEC_ECC_CFG_UECC; AM_FREERTOS; AM_PACKAGE_BGA; AM_DEBUG_PRINTF
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\third_party\exactle\ble-host\sources\stack\hci; ..\..\..\..\..\third_party\exactle\ble-host\sources\hci\ambiq; ..\src; ..\..\..\..\..\third_party\exactle\wsf\sources\port\freertos; ..\..\..\..\..\third_party\exactle\ble-profiles\sources\profiles\bas; ..\..\..\..\..\third_party\exactle\ble-host\sources\hci\include; ..\..\..\..\..\third_party\uecc; ..\..\..\..\..\third_party\exactle\wsf\include; ..\..\..\..\..\third_party\exactle\wsf\sources; ..\..\..\..\..\devices; ..\..\..\..\..\third_party\exactle\ble-host\sources\stack\cfg; ..\..\..\..\..\third_party\exactle\ble-profiles\sources\profiles\gatt; ..\..\..\..\..\third_party\exactle\ble-profiles\sources\apps\app; ..\..\..\..\..\third_party\exactle\ble-profiles\sources\services; ..\..\..\..\..\third_party\exactle\ble-host\sources\hci\ambiq\em9304; ..\..\..\..\..\third_party\exactle\ble-host\sources\stack\dm; ..\..\..\..\..\utils; ..\..\..\..\..\third_party\exactle\ble-profiles\sources\apps; ..\..\..\..\..\third_party\exactle\ble-profiles\sources\profiles\uribeacon; ..\..\..\..\..\mcu\apollo2; ..\..\..\..\..\third_party\exactle\ble-profiles\sources\profiles\hrps; ..\..\..\..\..\third_party\exactle\ble-host\include; ..\..\..\..\..\third_party\exactle\ble-host\sources\stack\l2c; ..\..\..\..\..\third_party\FreeRTOSv10.1.1\Source\portable\IAR\AMapollo2; ..\..\..\bsp; ..\..\..\..\..\third_party\exactle\ble-profiles\sources\profiles\hid; ..\..\..\..\..\third_party\exactle\ble-profiles\sources\profiles\gap; ..\..\..\..\..\third_party\exactle\ble-host\sources\stack\smp; ..\..\..\..\..\ambiq_ble\apps\ibeacon; ..\..\..\..\..\third_party\FreeRTOSv10.1.1\Source\include; ..\..\..\..\..\third_party\exactle\ble-profiles\sources\profiles; ..\..\..\..\..\third_party\exactle\ble-host\sources\sec\common; ..\..\..\..\..\third_party\exactle\ble-host\sources\stack\att; ..\..\..\..\..\third_party\exactle\wsf\sources\util; ..\..\..\..\..\third_party\exactle\ble-profiles\sources\profiles\rscp; ..\..\..\..\..\ambiq_ble\em9304; ..\..\..\..\..\third_party\exactle\ble-profiles\sources\profiles\include; ..\..\..\..\..\third_party\exactle\ble-profiles\include\app
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ble_freertos_ibeacon.bin
  ILINK.IlinkOutputFile: ble_freertos_ibeacon.out
  ILINK.IlinkIcfFile: ble_freertos_ibeacon.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\mcu\apollo2\hal\iar\bin\libam_hal.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; AM_PART_APOLLO2; WSF_TRACE_ENABLED; SEC_ECC_CFG=SEC_ECC_CFG_UECC; AM_FREERTOS; AM_PACKAGE_BGA; AM_DEBUG_PRINTF
  group (top)
    ../../../../../third_party/exactle/ble-host/sources/stack/hci/: hci_main.c
    ../../../../../third_party/exactle/ble-host/sources/hci/ambiq/em9304/: hci_drv_em9304.c
    ../../../../../third_party/exactle/ble-host/sources/stack/dm/: dm_adv.c dm_adv_ae.c dm_adv_leg.c dm_conn.c dm_conn_cte.c dm_conn_master.c dm_conn_master_ae.c dm_conn_master_leg.c dm_conn_slave.c dm_conn_slave_ae.c dm_conn_slave_leg.c dm_conn_sm.c dm_dev.c dm_dev_priv.c dm_main.c dm_past.c dm_phy.c dm_priv.c dm_scan.c dm_scan_ae.c dm_scan_leg.c dm_sec.c dm_sec_lesc.c dm_sec_master.c dm_sec_slave.c dm_sync_ae.c
    ../../../../../third_party/exactle/ble-host/sources/hci/ambiq/: hci_cmd.c hci_cmd_ae.c hci_cmd_cte.c hci_cmd_past.c hci_cmd_phy.c hci_core.c hci_core_ps.c hci_evt.c hci_tr.c hci_vs.c hci_vs_ae.c
    ../src/: ble_freertos_ibeacon.c radio_task.c rtos.c
    ../../../../../third_party/exactle/ble-profiles/sources/profiles/hrps/: hrps_main.c
    ../../../../../third_party/exactle/wsf/sources/port/freertos/: wsf_assert.c wsf_buf.c wsf_efs.c wsf_math.c wsf_msg.c wsf_os.c wsf_queue.c wsf_timer.c wsf_trace.c
    ../../../../../third_party/FreeRTOSv10.1.1/Source/portable/IAR/AMapollo2/: port.c portasm.s
    ../../../../../third_party/uecc/: uECC.c uECC_ll.c
    ../../../../../third_party/exactle/ble-profiles/sources/profiles/hid/: hid_main.c
    ../../../../../third_party/exactle/ble-profiles/sources/profiles/bas/: bas_main.c
    ../../../../../third_party/exactle/ble-profiles/sources/apps/app/common/: app_db.c app_hw.c app_ui.c ui_console.c ui_lcd.c ui_main.c ui_platform.c ui_timer.c
    ../../../../../third_party/exactle/ble-profiles/sources/profiles/gap/: gap_main.c
    ../../../../../third_party/exactle/ble-host/sources/sec/uecc/: sec_ecc.c
    ../../../../../third_party/exactle/ble-host/sources/stack/smp/: smpi_act.c smpi_sc_act.c smpi_sc_sm.c smpi_sm.c smpr_act.c smpr_sc_act.c smpr_sc_sm.c smpr_sm.c smp_act.c smp_db.c smp_main.c smp_non.c smp_sc_act.c smp_sc_main.c
    ../../../../../ambiq_ble/apps/ibeacon/: ibeacon_main.c
    ../../../../../third_party/exactle/ble-host/sources/sec/common/: sec_aes.c sec_aes_rev.c sec_ccm_hci.c sec_cmac_hci.c sec_ecc_debug.c sec_ecc_hci.c sec_main.c
    ../../../../../third_party/exactle/ble-host/sources/stack/cfg/: cfg_stack.c
    ../../../../../third_party/exactle/ble-profiles/sources/profiles/gatt/: gatt_main.c
    ../../../../../third_party/exactle/ble-profiles/sources/apps/hidapp/: hidapp_main.c
    ../../../../../third_party/exactle/ble-host/sources/stack/att/: attc_disc.c attc_main.c attc_proc.c attc_read.c attc_sign.c attc_write.c atts_ccc.c atts_csf.c atts_dyn.c atts_ind.c atts_main.c atts_proc.c atts_read.c atts_sign.c atts_write.c att_main.c att_uuid.c
    ../../../../../third_party/exactle/wsf/sources/util/: bda.c bstream.c calc128.c crc32.c print.c terminal.c wstr.c
    ../../../../../third_party/exactle/ble-profiles/sources/profiles/rscp/: rscps_main.c
    ../../../../../ambiq_ble/em9304/: em9304_init.c em9304_patches.c
    ../../../../../third_party/exactle/ble-host/sources/stack/l2c/: l2c_coc.c l2c_main.c l2c_master.c l2c_slave.c
    ../../../../../devices/: am_devices_em9304.c am_devices_led.c
    ../../../../../third_party/FreeRTOSv10.1.1/Source/portable/MemMang/: heap_2.c
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
    ../../../../../third_party/exactle/ble-profiles/sources/apps/app/: app_disc.c app_main.c app_master.c app_master_leg.c app_server.c app_slave.c app_slave_leg.c app_terminal.c
    ../../../../../third_party/FreeRTOSv10.1.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../third_party/exactle/ble-profiles/sources/services/: svc_batt.c svc_bps.c svc_core.c svc_cps.c svc_cscs.c svc_dis.c svc_gls.c svc_gyro.c svc_hid.c svc_hrs.c svc_hts.c svc_ipss.c svc_plxs.c svc_px.c svc_rscs.c svc_scpss.c svc_temp.c svc_uricfg.c svc_wdxs.c svc_wp.c svc_wss.c
    ./: startup_iar.c
